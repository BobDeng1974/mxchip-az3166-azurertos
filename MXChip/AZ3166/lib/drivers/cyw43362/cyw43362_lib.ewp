# IAR project cyw43362_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412RG ST STM32F412RG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: wifi_firmware_image=resources_firmware_DIR_43362_DIR_43362A2_bin
  ICCARM.CCIncludePath2: F4xx_lib\peripherals\libraries; F4xx_lib\peripherals\libraries\inc; F4xx_lib\peripherals; RTOS; network; ; internal; internal\bus_protocols; ..\tx; ..\nxd; ..\stm32f412_lib1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: cyw43362_lib.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: 43362A2_bin.c host_cm4.c platform.c platform_resource.c wiced_crypto.c wwd_ap.c wwd_ap_common.c wwd_buffer.c wwd_bus_common.c wwd_bus_protocol.c wwd_chip_specific_functions.c wwd_debug.c wwd_eapol.c wwd_internal.c wwd_management.c wwd_network.c wwd_platform.c wwd_platform_separate_mcu.c wwd_resources.c wwd_rtos.c wwd_SDIO.c wwd_sdpcm.c wwd_thread.c wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_sleep.c
    F4xx_lib/peripherals/: platform_gpio.c platform_mcu_powersave.c
  group Old_ST_LIB
    F4xx_lib/peripherals/libraries/src/: stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c
